Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: a3f63519-c0c8-4fca-b571-2d5e2364c56d, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T14:37:09+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12967550_TR_DAD4870_OBSW:28D4870B_TR_12967550_DAD4870_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, Výchozí Nový materiál, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Depth: 171 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28D4870B_TR_12967550_DAD4870_OBSW; sets with these values: 2

# IfcDistributionPort, Port_351299_1
Description: Flow; FlowDirection: SOURCEANDSINK
